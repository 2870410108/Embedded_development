# Keil uVision project demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: demo +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c snak_game.c
    ./tools/: I2C.c Delay_ms.c OLED12864.c init_timer.c
